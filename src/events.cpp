#include "lore.h"
namespace pond {
const char* eventName(Anomaly event){
    static const char* names[]={"水边无事","倒影迟到","仪表错时","明日报告","临时排水","鱼群交班","无人广播","水下敲门","失物认领","风起收据","旧灯复明","局部小雨","远处铃声"};
    return names[unsigned(event)<=EventCount?unsigned(event):0];
}
LorePage eventDossier(uint32_t code){
    static const LorePage cards[13]={
        {"岸边记录",{"暂时没有新的插曲。","水面很安静。","可以再钓一竿，也可以歇一会。","事件发生后会记在这里。","无需在动画出现时抢按键。","记录最多保留最近十二条。"}},
        {"倒影迟到",{"浮漂只投下了一根线。","水面却留下两道倒影。","其中一道慢了半拍才离开。","维护单称水面响应延迟。","暂不影响验收。","你没有再投第二根线。"}},
        {"仪表错时",{"怀表停在二十五点十三分。","一旁的旧仪表也跳了一格。","维修记录称每天慢一小时。","属于正常损耗。","你自己的时间没有发生变化。","厂里似乎有另一套作息。"}},
        {"明日报告",{"录音带里传来一次落水声。","随后报出了本次打捞结果。","报告日期填写的是明天。","归档员没有提前领取薪水。","理由是工作尚未发生。","声音在这里停了下来。"}},
        {"临时排水",{"管道晃了两下，涌出浑水。","几件旧东西从泥里露了出来。","接下来三竿更容易遇到旧物。","本次排放符合昨日标准。","今日标准仍在等待盖章。","效果按竿数计算，可以先歇着。"}},
        {"鱼群交班",{"一群鱼沿着管道排队游过。","接下来两竿，咬钩会快一些。","请勿占用员工通道。","最后一条鱼没有跟上队伍。","前面的鱼停下来等了它一下。","班组因此没有迟到。"}},
        {"无人广播",{"岸边广播亮起了一盏小灯。","请夜班人员在原岗位等候。","通知重复了两遍。","第二遍少念了一个名字。","人事科称名单已完成精简。","喇叭里随后传来翻纸的声音。"}},
        {"水下敲门",{"浮漂旁出现三圈规则波纹。","水下似乎有人轻轻敲门。","你暂时保持了安静。","本次来访尚未完成登记。","回到本竿结果页可按 E 轻敲。","继续垂钓也可以，无需限时回答。"}},
        {"失物认领",{"旧物上贴着一张湿的认领单。","签字栏写着一个沈字。","领取人尚未离开工作岗位。","暂由岸上人员代为保管。","认领单没有要求归还物品。","只要求不要把名字擦掉。"}},
        {"风起收据",{"风从断墙之间吹来。","一张旧收据贴在鱼线上。","上面是两份晚饭的价钱。","第二份的鱼被划掉了。","改成了两个鸡蛋。","风停后，你把纸压在石头下。"}},
        {"旧灯复明",{"远处的值班灯亮了一下。","一只飞虫在灯下绕了半圈。","它飞走后，灯才熄灭。","节能记录增加一次有效照明。","这回确实有人借到了光。","岸边重新安静下来。"}},
        {"局部小雨",{"水面出现了细密的雨点。","你的衣服和岸边都是干的。","气象记录称局部小雨。","具体区域填写为三号门以内。","天气预报因此没有出错。","一会儿后，水上的雨停了。"}},
        {"远处铃声",{"远处传来两声交班铃。","附近的鱼影都停了一下。","第三声迟迟没有响起。","你听见水里有人轻轻咳嗽。","广播提醒请勿代人签到。","随后一切恢复了原来的样子。"}}
    };
    unsigned id=code&255;
    if(id==unsigned(Anomaly::Knock)&&(code&(1u<<16)))return {"水下敲门／回应",{"你在竿柄上轻敲了一下。","水下只回了两下。","访客登记新增一名陪同人员。","姓名一栏没有要求填写。","你的收藏依然留在岸上。","波纹慢慢散开了。"}};
    if(id==unsigned(Anomaly::Broadcast)&&(code&0x300)==0x300)return {"无人广播／名单",{"广播说缺席人员已经到齐。","你看了一眼工牌和合照。","两份材料的人数仍然不同。","喇叭里有人挪动了一把椅子。","随后开始播放下班注意事项。","第一条是不要回头点名。"}};
    if(id==unsigned(Anomaly::Broadcast)&&(code&0x100))return {"无人广播／点名",{"广播念到了工牌上的名字。","水面比喇叭早一点回答了到。","通知称缺席人员正在补录。","请保留当前岗位。","你没有听见脚步声。","只有纸张被翻到了下一页。"}};
    return cards[id<=EventCount?id:0];
}
}
