#include "lore.h"
namespace pond {
namespace {
// Indexed by legacy silhouette and surface condition. No RNG, heap, or per-catch text storage.
const LorePage objects[8][4] = {
    {
        {"净水厂值班靴", {"来源：鞋底压着半张考勤表。", "最后一栏写着：全员到岗。", "签字处是同一人的笔迹。", "靴内有沙，没有脚。", "厂里大概只检查靴子。", "表格编号：净水三号。"}},
        {"长出苔藓的防护靴", {"来源：鞋舌上的保养标签。", "请保持内部干燥。", "苔藓已完整覆盖这行字。", "旁边另有一行手写记录：", "它比配发给我的宿舍暖和。", "落款只剩一个沈字。"}},
        {"刻着门牌的童靴", {"来源：鞋跟刻痕。", "三号门，晚饭前回家。", "门牌刻得很深，日期没有。", "里面塞着一枚干燥的纽扣。", "水一直没能进去。", "也许有人修补得很好。"}},
        {"夜班自亮靴", {"来源：安全用品领用单。", "夜间可见，杜绝工伤。", "附注：下班后请归还光源。", "鞋面还亮着。", "领用人一栏被水洗掉了。", "财务仍把它记作借出。"}}
    },
    {
        {"辉光汽水空瓶", {"来源：瓶身广告。", "每口都有明天的味道！", "背面写着：请勿重复灌装。", "瓶口却缠了七层封条。", "有人把明天喝了很多遍。", "押金凭瓶，概不凭人。"}},
        {"三号线水样瓶", {"来源：净水厂化验签。", "取样时间：停电后一小时。", "结论：颜色稳定。", "备注：样品自行移至窗边。", "复检栏写着：等它回来。", "值班人：沈。"}},
        {"反应堆冷却液瓶", {"来源：重复粘贴的瓶签。", "冷却液，禁止饮用。", "下面一层写着：员工饮水。", "最底层是同一批次编号。", "节约奖状印在瓶签背面。", "获奖部门：采购科。"}},
        {"永久夜灯补充液", {"来源：产品保修标签。", "承诺照亮您的余生。", "不承诺余生的具体长度。", "瓶内只剩一滴。", "附近的影子都朝向它。", "客服地址已经在水下。"}}
    },
    {
        {"净水三号门钥匙", {"来源：黄铜钥匙牌。", "紧急情况下请使用此钥匙。", "钥匙柜须经主管批准开启。", "主管室位于三号门后。", "流程图没有画返回箭头。", "钥匙齿上沾着白色门漆。"}},
        {"宿舍备用钥匙", {"来源：一小段防水纸。", "沈，你总忘带钥匙。", "这把放老地方，别告诉厂里。", "纸背列着两份晚饭的菜。", "第二份的鱼被划掉了。", "改成了两个鸡蛋。"}},
        {"模范员工专用钥匙", {"来源：钥匙环上的奖牌。", "恭喜获得自由出入资格。", "适用区域：本人工作岗位。", "钥匙只有头，没有齿。", "奖牌背面仍能照见人影。", "这也是本年度的福利之一。"}},
        {"未登记的归家钥匙", {"来源：贴在钥匙上的封条。", "无人认领，建议报废。", "封条被揭开又贴回三次。", "每次都添了一行新日期。", "最后一行没有公章。", "只有：再等一天。"}}
    },
    {
        {"应急饮水茶壶", {"来源：壶底的使用说明。", "煮沸可消除九成担忧。", "余下一成由用户自行承担。", "壶嘴塞着一团检测报告。", "报告上写着：无需煮沸。", "两者出自同一家工厂。"}},
        {"夜班休息室茶壶", {"来源：壶盖内的铅笔字。", "给沈留半壶，别再倒掉。", "今天他会早点下班。", "字迹被蒸汽洇开。", "壶把上绑着隔热的旧布。", "这种等待曾经很日常。"}},
        {"先进班组纪念壶", {"来源：壶腹上的表彰铭文。", "连续三百天无人投诉。", "小字：投诉箱已封存。", "这只壶没有开口。", "它从未装过水。", "从评奖标准看，十分干净。"}},
        {"自热旅行茶壶", {"来源：售后服务承诺。", "无需电源，持续温热。", "任何异响均属正常现象。", "壶盖每隔一会儿抬起一点。", "里面没有水。", "你决定先不问它在煮什么。"}}
    },
    {
        {"报时海螺", {"来源：岸边采样员记录。", "每到换班时间便低鸣一次。", "停工后仍保持原来的频率。", "记录员建议取消夜班。", "批复：海螺不在编制内。", "因此也不享有休假。"}},
        {"食堂排队海螺", {"来源：食堂遗失物清单。", "编号七十二，暂存柜内。", "壳上长着一圈餐票碎屑。", "师傅说它排了很久的队。", "最后还是没人给它打饭。", "理由是看不清员工照片。"}},
        {"刻字纪念海螺", {"来源：内壁的针刻字。", "如果你听见海，那就往东。", "如果你听见广播，别回答。", "刻字的人试过好几根针。", "有一根还卡在最深处。", "海螺现在很安静。"}},
        {"午夜广播海螺", {"来源：三号线异常报告。", "内部偶尔传来晚安广播。", "声音与退休播音员相似。", "人事部门确认他未退休。", "只是连续缺勤了很多年。", "缺勤通知已经寄出。"}}
    },
    {
        {"安全阀传动齿轮", {"来源：备件出库单。", "拆除后可提高生产效率。", "安全系数一栏改为留白。", "出库理由：消除停机原因。", "齿轮缺了一齿。", "另外那齿可能还在上班。"}},
        {"自动投饵机齿轮", {"来源：池塘设备维修簿。", "投饵机正常，鱼群增重。", "下周开始减少饲料预算。", "再下一页只剩一行：", "鱼已学会等待维修人员。", "此后未安排上门检修。"}},
        {"逆时钟齿轮", {"来源：考勤钟维修标签。", "故障表现：只记录上班。", "维修结论：符合管理需求。", "申请更换被退回两次。", "背面刻着一个小小的出口。", "指向的方向是齿轮中心。"}},
        {"仍在转动的齿轮", {"来源：仓库盘点附记。", "没有轴，没有电，也没停。", "主管建议列入节能成果。", "保管员问它什么时候休息。", "这句话被划进备注栏。", "备注栏不参与绩效统计。"}}
    },
    {
        {"停水期间供水通知", {"来源：净水三号公告。", "为确保供水，现暂停供水。", "恢复时间以恢复供水为准。", "请居民不要散播缺水消息。", "本通知由防水油墨印制。", "印刷部门用完了最后的水。"}},
        {"没寄出的家书", {"来源：信封里叠着的薄纸。", "我申请了明天调班。", "如果门还锁着，就别等我。", "钥匙放在我们说的地方。", "下半页被剪走了。", "剩下的部分没有写再见。"}},
        {"安全演习反馈表", {"来源：居民满意度调查。", "您是否满意本次疏散？", "选项一：非常满意。", "选项二：未能参加调查。", "背面印着集合地点示意图。", "出口被订书钉钉住了。"}},
        {"自动续发的录用信", {"来源：净水厂人事终端。", "恭喜！您的岗位为夜班员。", "上一任员工已获永久调休。", "报到请携带自己的杯子。", "信纸边缘盖着今日的日期。", "邮局的屋顶却早已塌了。"}}
    },
    {
        {"避难宣传玩具火箭", {"来源：儿童科普赠品。", "飞向一个更干净的明天。", "包装盒内没有发射按钮。", "说明书称此为家长模式。", "尾翼上粘着一颗乳牙。", "有人曾认真相信过它。"}},
        {"水下归航玩具火箭", {"来源：座舱里的小纸条。", "爸爸的船坏了，用这个。", "舱门被胶水封得很严。", "里面坐着半截铅笔。", "它没有到达任何星球。", "至少纸条一直是干的。"}},
        {"微型反应堆教具", {"来源：学校器材标签。", "外形为玩具，请勿当玩具。", "内置能源，请勿取出能源。", "遗失后请立即报告校长。", "校长电话贴在底座上。", "最后三位被烫穿了。"}},
        {"许愿用玩具火箭", {"来源：尾翼上的留言。", "愿新家有水，有窗，有人。", "另一个笔迹补了：有鱼。", "火箭里装着小小的石头。", "它的主人知道怎样让它沉底。", "也许这次本来就不是发射。"}}
    }
};
const LorePage newObjects[16] = {
    {"无声汽水瓶盖", {"来源：辉光饮料退货单。", "开启时应有清脆的一声。", "本批次的声音延迟至夜间。", "且会准确叫出购买者的名字。", "厂方同意退还瓶盖押金。", "姓名属于赠品，不予退回。"}},
    {"提前录好的交班带", {"来源：听潮试验录音室。", "录音时间早于当班人员出生。", "背景里有人抱怨工资太低。", "财务认定为历史遗留问题。", "磁带因此免于销毁。", "它是最早的薪资冻结依据。"}},
    {"双面夜班工牌", {"来源：人事科更正通知。", "正面照片已经离职。", "背面照片尚未到岗。", "两面都是同一个人。", "请勿同时支付两份工资。", "可以同时安排两份工作。"}},
    {"十三班制怀表", {"来源：班次优化试行办法。", "每日增设一班，不增加工时。", "新班次位于昨夜和昨夜之间。", "表盖内刻着沈的签退时间。", "人事系统无法识别该时间。", "所以他还没有迟到过。"}},
    {"只接内线的听筒", {"来源：通讯费用说明。", "线路已剪断，仍有来电。", "对方声称在您隔壁值班。", "隔壁房间于开厂前被封死。", "本通话按内部交流收费。", "墙的厚度不影响资费。"}},
    {"延迟下班的手镜", {"来源：员工仪容检查表。", "镜中人总比本人晚走一步。", "事故当晚，它没有跟着走。", "留存科建议双方分开考勤。", "镜面已擦干净。", "里面的人仍在擦拭。"}},
    {"请勿应答的交班铃", {"来源：留存科暂行规定。", "响两次可以换班。", "响三次请不要回答到。", "若您已经回答，请留在原地。", "我们需要知道谁接了班。", "否则夜班补贴无法入账。"}},
    {"全是明天的骰子", {"来源：员工抽签福利说明。", "六面均刻有明天休息。", "每到明天，字样自动更新。", "此物从未开出无效承诺。", "工会决定继续使用。", "你把它放下时，它又转了一面。"}},
    {"多一道影子的合照", {"来源：三号门开放日照片。", "背面列了十二个人名。", "正面站着十三个人。", "摄影师坚持按十二人收费。", "多出来的人没有占用胶卷。", "它站在所有人视线的交点。"}},
    {"已妥善处理印章", {"来源：事故结案办公用品。", "盖过的记录会少一行文字。", "印章无需补充印油。", "小字提醒：不要盖在人名上。", "人事科借用后给予好评。", "理由是报表终于对齐了。"}},
    {"无梦轮休片药盒", {"来源：厂医配发说明。", "服后不会梦见陌生的走廊。", "药片已经全被取走。", "盒底却多出一条走廊的图。", "厂医建议把盒子也收起来。", "这不计入免费医疗范围。"}},
    {"指向值班者的罗盘", {"来源：水下设备寻回手册。", "指针不指北，只指向值班者。", "停工后持续指向三号井底。", "主管确认井下没有员工。", "故将设备登记为精度不足。", "它仍准确地避开了主管。"}},
    {"防回声面罩", {"来源：听潮试验防护清单。", "可过滤粉尘和大部分应答。", "听见自己的名字时请闭嘴。", "呼吸不受影响。", "表达意见也在过滤范围内。", "本厂已实现安静的工作环境。"}},
    {"昨日天气收音机", {"来源：生活服务广播。", "本机只播报昨日天气。", "事故当天起，每天都有小雨。", "镇上已经多年没有下雨。", "气象站拒绝修正旧档。", "毕竟它从不预报错误的未来。"}},
    {"不够长的测深尺", {"来源：三号井测绘记录。", "垂直放入一米，取回两米。", "重复试验不增加采购成本。", "工程师建议暂缓测到底。", "财务建议继续测。", "本季度钢材预算已经用完。"}},
    {"从里面夹紧的铅封", {"来源：三号井封存验收单。", "封口完整，夹痕位于内侧。", "验收组没有携带开封工具。", "这证明封存工作准备充分。", "签字需要两人。", "纸上已有一个湿漉漉的名字。"}}
};
// One closed trail spans all 24 physical types. Each page can also stand alone out of order.
// References use actual catalogue names, not unavailable quest items or automatic unlocks.
const unsigned links[ObjectTypes] = {2,22,16,18,21,20,17,3,4,14,11,5,6,23,10,1,7,0,8,9,12,13,19,15};
const LorePage evidence[ObjectTypes] = {
    {"留存科／遗失人员附件", {"沈的靴子先从三号井浮上来。", "人事科据此判定本人已离岗。", "技术科认为靴子不能代表本人。", "两科同意先扣除制鞋费用。", "那把备用钥匙随后也浮了上来。", "另见：遗落钥匙"}},
    {"留存科／立项材料", {"三号井的水会提前复述人声。", "项目因此获名听潮。", "目标是减少电话线路开支。", "测深员建议先确认井底位置。", "财务要求两项研究共用一把尺。", "另见：量尺"}},
    {"留存科／门禁复核", {"家属用备用钥匙打开三号门。", "岗亭外的脚印到此变成两行。", "门禁只登记了一次离场。", "多出的一人被归入陪同人员。", "档案附上了开放日的合照。", "另见：照片"}},
    {"留存科／休息室物证", {"茶壶整晚停在十三班的座位上。", "隔壁的空椅子先出现了压痕。", "厂医判断为共同疲劳。", "建议在岗人员按时休息。", "药品费用按座位数分摊。", "另见：药盒"}},
    {"留存科／扩散调查", {"停机后，海螺仍在重复交班声。", "镇外也开始有人听见三次铃。", "部门决定暂停受理耳鸣投诉。", "这使扩散曲线恢复了平稳。", "只有旧广播还在报告降雨。", "另见：收音机"}},
    {"留存科／停机方案", {"沈拆掉了听潮管线的传动齿轮。", "泵停了，管道里还在点名。", "停机按计划完成，点名不在计划。", "留存科建议先停止回答。", "采购科找出了早已到货的面罩。", "另见：面罩"}},
    {"留存科／未寄出公函", {"事故报告最初列有沈的名字。", "报送前改为临时岗位调整。", "家属收到的是自动续发录用信。", "人事科解释姓名来自旧模板。", "结案时又盖了一遍处理章。", "另见：印章"}},
    {"留存科／家属来访物", {"小孩把火箭沿三号门的水沟放走。", "纸条写着带爸爸回家。", "门卫按未经批准的运输登记。", "当夜休息室传来了烧水声。", "值班表上没有安排任何人。", "另见：小茶壶"}},
    {"留存科／召回凭证", {"听潮用过的空瓶流入汽水厂。", "召回范围仅包含瓶身，不含声音。", "客服记录了第一批夜间来电。", "每位来电者都叫得出客服姓名。", "同样的声音随后进入了海螺。", "另见：海螺"}},
    {"留存科／试验原声", {"磁带中，沈问井下是谁在值班。", "他的声音先于问题回答了到。", "随后有人摇了三次交班铃。", "试验组将其计为成功接通。", "没有人为第三次铃填写说明。", "另见：手铃"}},
    {"留存科／人员锚定规程", {"工牌是听潮试验的接线凭证。", "姓名朝水，照片朝向值班者。", "沈的工牌隔夜多出第二张照片。", "新增人员没有提出工资要求。", "人事科先给他安排了新的班次。", "另见：怀表"}},
    {"留存科／额外班次", {"怀表多出的那一格被称为十三班。", "沈在这一格里签过退。", "管线却仍用他的声音回答。", "值班员认为必须先把水泵停掉。", "维修单选择了成本最低的拆法。", "另见：生锈齿轮"}},
    {"留存科／事故夜通话", {"家属问沈什么时候能离开。", "听筒里回答：门开时不要点名。", "声音很近，背景里却一直有水。", "话费清单认定双方在同一室内。", "沈的家书后来出现在听筒下面。", "另见：漂流信"}},
    {"留存科／撤离点人数", {"镜中仍留着一个没有下班的人。", "撤离名单却已显示全员离场。", "留存科要求封井人员不要回头。", "理由写的是防止重复清点。", "最后一道铅封由谁夹紧，未记录。", "另见：铅封"}},
    {"留存科／应答转接规则", {"两声交班，第三声在等待姓名。", "应答后，空岗位会开始有人值守。", "是否仍为原来的人，尚未确认。", "因此必须携带工牌。", "这样至少有一个名字可以追责。", "另见：工牌"}},
    {"留存科／结案后的采购", {"井已封，十三班仍无人替换。", "福利骰子每天保证明天轮休。", "有人提出它也许只是重复过去。", "留存科将也许列为观察结论。", "新的取样瓶已经得到采购批准。", "另见：玻璃瓶"}},
    {"留存科／重复曝光说明", {"合照里多出的轮廓没有自己的脸。", "它总朝着正在读名字的人站。", "摄影师被要求不要寄送底片。", "补偿是一张永不过期的取件单。", "孩子在背面画过一艘回家的船。", "另见：玩具火箭"}},
    {"留存科／姓名修订说明", {"处理章盖掉了沈的缺勤记录。", "水里的声音随后只说自己的班次。", "去向一栏因此可以保持空白。", "事故统计回到了零人失踪。", "仓库却还需要处理他的靴子。", "另见：旧靴子"}},
    {"留存科／共同梦境随访", {"所有服药者画出了同一条走廊。", "图的尽头都是三号门内侧。", "厂医删除了建议延长睡眠一项。", "公共说明改为避免睡前饮汽水。", "这恰好与饮料召回通告一致。", "另见：瓶盖"}},
    {"留存科／初次定位试验", {"测深尺没有触底，罗盘却停住了。", "指针指向尚未下井的沈。", "项目组称其为人员定位突破。", "沈要求保留当天的完整录音。", "此要求获批，因为磁带可重复用。", "另见：录音带"}},
    {"留存科／不应答作业", {"戴面罩的人停止回答三次铃声。", "管道中的点名逐渐减少。", "有人仍在用家属的声音喊沈。", "留存科要求仅保留一条内线。", "通讯科表示它早就没有线了。", "另见：听筒"}},
    {"留存科／停工后的气象", {"收音机的雨声来自三号门内。", "播音员每晚都说撤离已经结束。", "最后一句总比昨晚晚上一点。", "镇上因此每天获得额外的寂静。", "直到手镜里的人抬起头来。", "另见：手镜"}},
    {"留存科／井深争议", {"三号井深度大于厂区图纸总长。", "测绘组排除了尺子不足的可能。", "无法排除图纸过于乐观。", "工程预算仍按原来的井深执行。", "于是他们改用罗盘寻找井底。", "另见：罗盘"}},
    {"留存科／封存验收结论", {"铅封从里面闭合，铃声暂时停止。", "验收表写着至少一人仍在值班。", "主管将一人改成一个岗位。", "厂外从此每天都有人梦见明天。", "工会把轮休骰子留了下来。", "另见：骰子"}}
};
const LorePage fish[8] = {
    {"溪鱼群／水质指示种", {"来源：净水三号采样手册。", "鱼群存活说明水质安全。", "出现新器官不影响判定。", "今年已第四次修改插图。", "文字部分从未更新。", "旧插图被用来包食堂的鱼。"}},
    {"团鱼群／配给适应种", {"来源：食堂营养科便笺。", "体形圆润，适宜按个配给。", "剖开后发现大半是空气。", "会计认为这不影响按个计价。", "厨师把刀放下了。", "他今天已经加过一次班。"}},
    {"长尾鱼群／越界游动种", {"来源：围网管理处报告。", "鱼身留在网内，尾巴在外。", "建议按头部位置统计户籍。", "有人在尾鳍上系过细线。", "线头另一端是三号门钥匙。", "报告没有解释是谁钓谁。"}},
    {"河豚群／压力响应种", {"来源：劳动安全宣传册。", "受惊膨胀是正常保护反应。", "员工请勿模仿。", "厂医建议降低环境压力。", "最终采购了更大的鱼缸。", "厂医也换了一个办公室。"}},
    {"带鱼群／管线栖居种", {"来源：管道维修工作单。", "细长个体可通过三号滤网。", "改装后仍能通过。", "第三次改装省去了滤网。", "此后再无堵塞投诉。", "有居民反映水龙头怕光。"}},
    {"角鱼群／硬化骨板种", {"来源：渔获回收价格表。", "鱼肉按斤，骨板按件。", "完整个体按较低者结算。", "鱼贩试图把它登记成螺丝。", "窗口要求补交检疫证明。", "它在秤上轻轻顶了一下。"}},
    {"扁鱼群／沉积伏生种", {"来源：河床清淤工程记录。", "该鱼长期紧贴沉积层。", "腹部保留旧标语的反印。", "辨认结果：为了您的健康。", "剩下半句在另一条鱼身上。", "工程队决定等下一次清淤。"}},
    {"灯鱼群／自照明种", {"来源：照明节能试点报告。", "一条可照亮半张值班桌。", "夜里会游向写信的那一边。", "后来桌边不再有人写信。", "鱼仍每天亮到换班时间。", "报告建议扣减电费补贴。"}}
};
const LorePage sites[3] = {
    {"苇岸／岗亭抄录", {"三号门外的岗亭留下两把椅子。", "一把朝着厂里，一把朝着河。", "墙上写着：夜班请结伴离开。", "有人把结伴二字圈了起来。", "签退表的最后一栏空着。", "门边却有两只洗干净的杯子。"}},
    {"暮湾／广播底稿", {"各位居民，明日照常供水。", "请勿相信水中有人说话。", "如有听见，请记录姓名。", "底稿背面写着：沈还在里面。", "请再播一次，不要念名字。", "值班员只在最后一句打了勾。"}},
    {"星潭／岸边留言", {"这里曾是员工家属的野餐点。", "石桌上刻着三号门外见。", "下面另有一行：已经开了。", "两行字用的不是同一把刀。", "桌下藏着一只空饭盒。", "盒盖内侧画了一条很普通的鱼。"}}
};
const char* patterns[8][2] = {
    {"体表素色，未见明显花纹。", "旧手册把这称为正常。"},
    {"点状斑纹沿体侧散开。", "计数员曾把它们当成年轮。"},
    {"横向条纹越过鳃盖。", "像一道没能关上的百叶窗。"},
    {"竖向条纹分隔鳞片。", "很适合监测站逐格填表。"},
    {"体侧有连续的棋格斑纹。", "据说曾有人拿它练习识字。"},
    {"环状花纹绕着鳞片扩散。", "像水面记住了每一次落物。"},
    {"深浅色块在腹侧交叠。", "与厂区旧制服的补丁相似。"},
    {"斜向鳞纹在光下连成细线。", "尚不清楚这是伪装还是警告。"}
};
const char* ornaments[4][2] = {
    {"未观察到额外的发光突起。", "这并不能作为饮用水证明。"},
    {"头部可见灯状突起。", "没有发现可以关掉它的开关。"},
    {"腹侧长出两条丝带状延伸。", "采样表暂列为多余的部分。"},
    {"背侧突起形如小冠。", "回收站不承认它的贵族身份。"}
};
const char* surfaces[4][2] = {
    {"表面保留普通磨损。", "普通是相对这片水域而言。"},
    {"苔藓覆盖接缝与凹槽。", "这里的东西很少真正闲置。"},
    {"刻纹尚能在侧光下辨认。", "有人希望它比自己留得更久。"},
    {"表面散布星点状亮斑。", "星尘只是旧分类表的叫法。"}
};
}
namespace {
struct Annotation { unsigned a,b; LorePage page; };
const Annotation notes[AnnotationCount] = {
    {10,16,{"新增批注／工牌与合照", {"合照背面没有工牌上的名字。", "但每个人都给他留了位置。", "摄影师说这里只收座位费。", "人事科确认空位不计入编制。", "两份记录因此都没有错误。", "请勿为方便统计补写姓名。"}}},
    {9,11,{"新增批注／磁带与怀表", {"录音中的交班声对上了十三班。", "只是磁带要比怀表早响一遍。", "沈在第二遍才回答。", "两遍都被记作按时到岗。", "他只领到一份夜班补贴。", "财务不认可提前发生的加班。"}}},
    {14,20,{"新增批注／手铃与面罩", {"第三声铃没有固定的音调。", "面罩内侧的划痕却总是三道。", "至少有人练习过保持安静。", "留存科据此认定培训有效。", "讲师姓名一栏暂时空着。", "课后点名已取消。"}}},
    {1,22,{"新增批注／水样与测深尺", {"瓶内水位对应尺上没有的刻度。", "放在一起时，尺子不再变长。", "瓶子却显得比昨天更深。", "采购科建议只保留较便宜的一件。", "测绘员没有签字。", "他的笔先落到了瓶底。"}}},
    {19,5,{"新增批注／罗盘与齿轮", {"齿轮停了，指针还指着井下。", "那里仍有一个岗位在运转。", "设备科认为这证明没有停工。", "维修科要求返还停机检修费。", "两个部门共用同一张桌子。", "桌下传来了第三个人的叹气。"}}},
    {12,4,{"新增批注／听筒与海螺", {"海螺补齐了通话里缺失的雨声。", "家属说当晚屋里没有下雨。", "话费清单仍坚持双方在同一室内。", "客服建议把房间看得大一些。", "家属没有接受这项建议。", "他们家的窗户已经够小了。"}}},
    {6,2,{"新增批注／家书与钥匙", {"信封的压痕与钥匙齿完全吻合。", "沈把它放在了说好的地方。", "门禁记录只剩开门这一项。", "离场人数被水泡掉了一半。", "主管称剩下的一半足以结案。", "家属没有来领那张结案证明。"}}},
    {7,3,{"新增批注／火箭与茶壶", {"玩具尾翼的胶与壶把补丁相同。", "有人在同一晚修好了两件东西。", "一件送出去，一件留下来等。", "家属申请领回茶壶。", "仓库要求原领用人本人签字。", "于是他们又给壶盖添了块布。"}}},
    {17,0,{"新增批注／印章与旧靴", {"注销名单上找不到靴子的主人。", "考勤表却保留了他的鞋码。", "这足以证明他按规定着装。", "安全事故数仍然为零。", "遗失物数量增加了一件。", "两张报表都顺利通过了审核。"}}},
    {18,21,{"新增批注／药盒与广播", {"药盒上的走廊通向广播里的雨。", "停药后，雨声不会消失。", "只是播音员开始劝人早些休息。", "厂医把它列为辅助治疗。", "气象站申请分摊医疗补贴。", "患者名单尚未收到任何回复。"}}},
    {13,23,{"新增批注／手镜与铅封", {"镜中的划痕与铅封内侧相合。", "封井的人似乎留在了同一侧。", "验收组建议将内外改称两侧。", "这样就不必修改撤离结论。", "配套物品已找齐。", "原持有人仍缺一件。"}}},
    {8,15,{"新增批注／瓶盖与骰子", {"瓶盖的赠品姓名出现在骰子底下。", "承诺明天休息的原来是同一批人。", "召回通知没有包含这些承诺。", "客服说它们尚未过期。", "骰子又轻轻转了一面。", "今天依旧可以放心上班。"}}}
};
}
uint32_t unlockedAnnotations(uint32_t objects) {
    uint32_t mask=0;
    for(unsigned i=0;i<AnnotationCount;++i){uint32_t pair=(1u<<notes[i].a)|(1u<<notes[i].b);if((objects&pair)==pair)mask|=1u<<i;}
    return mask;
}
const LorePage* annotationFor(const Catch& c,uint32_t objects) {
    if(!c.object())return nullptr;
    unsigned type=c.objectType();
    for(const auto& note:notes){uint32_t pair=(1u<<note.a)|(1u<<note.b);if((note.a==type||note.b==type)&&(objects&pair)==pair)return &note.page;}
    return nullptr;
}
unsigned evidenceNext(unsigned type) { return type < ObjectTypes ? links[type] : ObjectTypes; }
LorePage dossier(const Catch& c, unsigned page, uint32_t knownObjects) {
    if(page==3){if(const auto* note=annotationFor(c,knownObjects))return *note;}
    if (page % 3 == 0) {
        if (!c.object()) return fish[c.body()];
        unsigned type=c.objectType();
        return type<8 ? objects[type][(c.form>>6)&3] : newObjects[type-8];
    }
    if (page % 3 == 1) return c.object() ? evidence[c.objectType()] : sites[c.spot % 3];
    if (c.object()) {
        const auto& s = surfaces[(c.form >> 6) & 3];
        return {"留存科／入库附记", {s[0], s[1], "按暂行规定，物证不得独自离库。", "如自行离库，请为其补办出差。", "档案允许互相矛盾，请勿点名核实。", "本条规定也适用于规定的起草人。"}};
    }
    const auto& p = patterns[c.pattern()]; const auto& o = ornaments[c.ornament()];
    return {"标本观察／变异记录", {p[0], p[1], o[0], o[1], "外形记录与食用安全无关。", "本终端没有配发餐具。"}};
}
}
